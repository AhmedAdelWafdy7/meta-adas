FILES:${PN} += " \
${libdir}/libmosquitto.so.* \
${libdir}/libmosquittopp.so.* \
${bindir}/mosquitto_pub \
${bindir}/mosquitto_sub \
${bindir}/mosquitto_rr \
"
