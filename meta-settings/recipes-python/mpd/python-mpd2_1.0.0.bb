SUMMARY = "A Python MPD client library"
HOMEPAGE = "https://github.com/Mic92/python-mpd2"
LICENSE = "LGPLv3+"
LIC_FILES_CHKSUM = "file://LICENSE.txt;md5=e6a600fd5e1d9cbde2d983680233ad02"

SRC_URI = "https://files.pythonhosted.org/packages/a8/12/63bdb3ee8e0bd7dd0476e79f0f130c1caeff408a1b1e5531ae9891805f7d/python-mpd2-1.0.0.tar.bz2"
SRC_URI[md5sum] = "53a67260a39865bb12e4fbb570597fa0"

PYPI_PACKAGE = "python-mp2"

inherit setuptools3

RDEPENDS_${PN} += " \
"
