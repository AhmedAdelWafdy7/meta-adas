# Extend the base recipe search path to $HERE/init-ifupdown
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
