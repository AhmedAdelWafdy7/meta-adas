
PACKAGECONFIG:append = "accsssibility gles2 eglfs fontconfig linuxfb tslib"
PACKAGECONFIG:remove = "examples tests x11"
DEPENDS += "userland"
